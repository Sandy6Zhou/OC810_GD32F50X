# Keil uVision project OC810_GD32F505V.uvprojx, settings and files
target GD32F505VGT7 (6150000::V6.15::ARMCLANG)
  device: GD32F505VG GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x030000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: GD32F50X,GD32F50X_HD,GD32F505,USE_STDPERIPH_DRIVER
  c include: ..\code\app;..\code\inc;..\code\log;..\code\memory;..\code\driver;..\code\utility;..\code\os_abs;..\..\..\Library\Firmware\CMSIS;..\..\..\Library\Firmware\CMSIS\GD\GD32F50x\Include;..\..\..\Library\Firmware\GD32F50x_standard_peripheral\Include;..\..\..\Library\Utilities;..\..\..\Third_Party\FreeRTOSv10.3.1\FreeRTOS\Source\include;..\..\..\Third_Party\FreeRTOSv10.3.1\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\..\Third_Party\Segger_RTT\RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group APP
    ../code/app/: main.c gd32f50x_it.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F50x/Source/: system_gd32f50x.c
  group OS_ABS
    ../code/os_abs/: my_os.c
  group FreeRTOS
    ../../../Third_Party/FreeRTOSv10.3.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_Party/FreeRTOSv10.3.1/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../../../Third_Party/FreeRTOSv10.3.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group GD32F50x_Peripherals
    ../../../Library/Firmware/GD32F50x_standard_peripheral/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
  group GD32F50x_EVAL
    ../../../Library/Utilities/: gd32f503v_eval.c
  group LOG
    ../code/log/: my_log.c rtt_logger.c uart_logger.c
    ../../../Third_Party/Segger_RTT/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group MEMORY
    ../code/memory/: my_safe_memory.c
  group drivers
    ../code/driver/: uart_driver.c gpio_driver.c
  group Startup
    ../../../Library/Firmware/CMSIS/GD/GD32F50x/Source/ARM/: startup_gd32f50x.s
  group Uitility
    ../code/utility/: ringbuffer.c
software components: CMSIS:CORE 5.4.0
