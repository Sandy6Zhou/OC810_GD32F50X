# Keil uVision project Bootloader.uvprojx, settings and files
target GD32F505VG_Bootloader (6150000::V6.15::ARMCLANG)
  device: GD32F505VG GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x030000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: fromelf --bin -o .\Objects\Bootloader.bin .\Objects\Bootloader.axf
  AfterMake: ..\..\tools\build_bootloader.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: USE_STDPERIPH_DRIVER, GD32F50X, GD32F505
  c include: ..\code;..\..\Library\Firmware\CMSIS;..\..\Library\Firmware\CMSIS\GD\GD32F50x\Include;..\..\Library\Firmware\GD32F50x_standard_peripheral\Include;..\..\Third_Party\Segger_RTT\RTT\RTT;..\..\Third_Party\Segger_RTT\RTT\Config
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Application
    ../code/: my_bl_bootconf.c my_bl_flash.c my_bl_main.c my_bl_ota.c my_bl_utils.c my_bl_log.c gd32f50x_it.c systick.c
  group CMSIS
    ../code/: system_gd32f50x.c
  group Peripherals
    ../../Library/Firmware/GD32F50x_standard_peripheral/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
  group Startup
    ../code/: startup_gd32f50x.s
  group RTT
    ../../Third_Party/Segger_RTT/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
